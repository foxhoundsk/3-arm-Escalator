# Keil uVision project 3_Lane_Escalator.uvproj, settings and files
target Target 1 (MCS-51)
  device: EFM8LB12F64E-QFN32 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xF9FF) CLOCK(72000000)
  output: 3_Lane_Escalator +hex
  c flags: Optimize=4 SizeSpeed=1
  c include: .\Inc;C:\Keil_v5\C51\INC\SiLABS\shared\si8051Base;C:\Keil_v5\C51\INC\SiLABS\EFM8LB1\inc
  group Source Group 1
    ./: SILABS_STARTUP.A51
  group Src
    ./Src/: esp8266.c uart.c main.c interrupt.c Escalator.c
  group Inc
    ./Inc/: uart.h main.h esp8266.h Escalator.h compiler_defs.h endian.h SI_EFM8LB1_Defs.h SI_EFM8LB1_Devices.h SI_EFM8LB1_Register_Enums.h si_toolchain.h stdbool.h stdint.h
